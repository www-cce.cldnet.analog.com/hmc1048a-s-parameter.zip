! Analog Devices Inc.
! "! One Technology way, P.O Box 9106"
! "! Norwood, MA 02062-9106"
! http://www.analog.com
! Tel: 781-329-4700
! Device:  HMC1048A
! Description: MMIC Fundamental  Mixer
! Frequency:  2.25 -  18 GHz Double-Balanced Mixer
! Package:  LC3B  - Ceramic- 12 pins
! "! Ports:  1,LO Port De-embedded from: 2GHz-18GHz @ 13dBm power"
! Data:  The device was measured on evaluation board 08-047919A.
!  The evaluation circuit board was modeled and simulated.  This was use
!  to removed the evaluation board circuit from the measured data.
!  The reference plane is the center of the package pin.
! Misc:
! Date Measured:  08-22-2017
! Date:  01-09-2018
! Note:
!  Analog supplies this data as a sample of measured data at the package pin for
!  for this package product.  Your particular data for this product may vary.
!  Data was taken at 25 degrees C.
!  Analog reserves the right to change this data at anytime.
# MHz S MA R 50
! Worked out from all points (reflecting one-port):
!   534 points, 2.02 GHz to 18.01 GHz, reference 50 ohm
!   lowest |S11| = 1.5 dB at 2.08 GHz (marker M1)
!   phase of S11 starts at 74 deg and turns -610 deg over the sweep
!   the Smith chart shows 2.02 GHz to 2.65 GHz only
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! magnitudes (dB):
! f  S11
! 2.02 GHz  1.5
! 2.08 GHz  1.5
! 2.29 GHz  8.9
! 2.56 GHz  13.1
! 2.74 GHz  15.0
! 3.04 GHz  17.3
! 3.34 GHz  19.2
! 3.64 GHz  20.7
! 4.03 GHz  21.5
! 4.72 GHz  20.5
! 5.17 GHz  19.0
! 5.41 GHz  18.1
! 6.04 GHz  15.9
! 6.88 GHz  12.9
! 8.02 GHz  11.4
! 8.29 GHz  11.1
! 9.01 GHz  12.1
! 10.03 GHz  14.7
! 11.23 GHz  18.5
! 12.04 GHz  19.8
! 12.94 GHz  21.1
! 13.18 GHz  20.4
! 13.42 GHz  21.5
! 14.02 GHz  20.7
! 15.25 GHz  18.4
! 16.03 GHz  20.0
! 17.2 GHz  21.5
! 18.01 GHz  20.7
